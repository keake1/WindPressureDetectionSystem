# Keil uVision project TempertureHumiditySensor.uvproj, settings and files
target Target_1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(11059200)
  output: TempertureHumiditySensor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\User\Inc
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/Src/: main.c gpio.c digital_tube.c task.c timer.c uart.c aht30.c iic.c protocol.c
