# Keil uVision project Project.uvproj, settings and files
target Project (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User;..\App
  group User
    ../User/: main.c
  group App
    ../App/: RI2C.c delay.c uart1.c SPL06_001.c adc.c timer2.c digital_cube.c addr.c uart2.c ModeBusRTU.c timer0.c SPL07-003.c
  group Doc
    ../Doc/: Note.txt
